# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx; MBEDTLS_CONFIG_FILE=<tc_tls_config.h>
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\qcloud-iot-explorer-sdk-embedded-c\include; ..\..\..\..\..\..\Middlewares\Third_Party\qcloud-iot-explorer-sdk-embedded-c\include\exports; ..\..\..\..\..\..\Middlewares\Third_Party\qcloud-iot-explorer-sdk-embedded-c\sdk_src\internal_inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\lis2dw12; ..\..\..\..\..\..\Drivers\BSP\Components\lis2mdl; ..\..\..\..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso; ..\..\..\..\..\..\Drivers\BSP\Components\stts751; ..\..\..\..\..\..\Drivers\BSP\IKS01A3; ..\..\..\..\..\..\Middlewares\Third_Party\qcloud-iot-explorer-sdk-embedded-c\external_libs\mbedtls\include; ..\..\..\..\..\..\Middlewares\Third_Party\qcloud-iot-explorer-sdk-embedded-c\external_libs\mbedtls\port; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: app_x-cube-mems1.c board.c freertos.c main.c nucleo_l476rg_bus.c retarget.c shell.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/IKS01A3
    ../../../../../../Drivers/BSP/IKS01A3/: iks01a3_env_sensors.c iks01a3_env_sensors_ex.c iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/Third_Party/mbedTLS/lib
    ../../../../../../Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/external_libs/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Middlewares/Third_Party/mbedTLS/port
    ../../../../../../Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/external_libs/mbedtls/port/: entropy_hardware.c net_sockets_alt.c timing_alt.c
  group Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/at_device
    ../../../../../../Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/platform/at_device/esp8266/: at_device_esp8266.c
  group Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/network_at
    ../../../../../../Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/sdk_src/network/at_socket/: at_client.c at_socket_inf.c at_utils.c network_at_tcp.c
    ../../../../../../Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/sdk_src/network/: network_interface.c
    ../../../../../../Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/sdk_src/network/tls/: network_tls.c
  group Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/platform
    ../../../../../../Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/platform/os/freertos/: HAL_AT_UART_freertos.c HAL_Device_freertos.c HAL_OS_freertos.c HAL_Timer_freertos.c
    ../../../../../../Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/platform/tls/mbedtls/: HAL_TLS_mbedtls.c
  group Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/sample
    ../Src/tc_iot_examples/data_template_iCube/: iCube_data_template_sample.c
    ../Src/tc_iot_examples/data_template_light/: light_data_template_sample.c
    ../Src/tc_iot_examples/mqtt/: mqtt_sample.c
  group Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/sdk_core
    ../../../../../../Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/sdk_src/services/data_template/: data_template_aciton.c data_template_client.c data_template_client_common.c data_template_client_json.c data_template_client_manager.c data_template_event.c
    ../../../../../../Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/sdk_src/utils/: json_parser.c json_token.c qcloud_iot_ca.c qcloud_iot_device.c qcloud_iot_log.c string_utils.c utils_aes.c utils_base64.c utils_getopt.c utils_hmac.c utils_list.c utils_md5.c utils_ringbuff.c utils_sha1.c utils_timer.c
    ../../../../../../Middlewares/Third_Party/qcloud-iot-explorer-sdk-embedded-c/sdk_src/protocol/mqtt/: mqtt_client.c mqtt_client_common.c mqtt_client_connect.c mqtt_client_net.c mqtt_client_publish.c mqtt_client_subscribe.c mqtt_client_unsubscribe.c mqtt_client_yield.c
