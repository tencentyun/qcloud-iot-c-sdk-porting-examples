# Keil uVision project Tencent_icube_based_Nucleo_L476.uvprojx, settings and files
target Tencent_icube_based_Nucleo_L476 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Tencent_icube_based_Nucleo_L476 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c include: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/include;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/include/exports;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/sdk_src/internal_inc;../Drivers/BSP/Components/lsm6dso/;../Drivers/BSP/Components/lis2dw12/;../Drivers/BSP/Components/lis2mdl/;../Drivers/BSP/Components/hts221/;../Drivers/BSP/Components/lps22hh/;../Drivers/BSP/Components/stts751/;../Drivers/BSP/IKS01A3/;../Drivers/BSP/Components/Common/
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: main.c freertos.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c board.c retarget.c app_x-cube-mems1.c nucleo_l476rg_bus.c shell.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/qcloud-iot-sdk-embedded-c/sdk_core
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/sdk_src/protocol/mqtt/: mqtt_client.c mqtt_client_common.c mqtt_client_connect.c mqtt_client_net.c mqtt_client_publish.c mqtt_client_subscribe.c mqtt_client_unsubscribe.c mqtt_client_yield.c
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/sdk_src/utils/: ca.c device.c json_parser.c json_token.c qcloud_iot_log.c string_utils.c utils_aes.c utils_base64.c utils_hmac.c utils_list.c utils_md5.c utils_sha1.c utils_timer.c utils_ringbuff.c
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/sdk_src/services/shadow/: shadow_client.c shadow_client_common.c shadow_client_json.c shadow_client_manager.c
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/sdk_src/services/event/: qcloud_iot_event.c
  group Middlewares/qcloud-iot-sdk-embedded-c/sample
    ../Src/tc_iot_examples/iot_hub_platform/: mqtt_sample.c shadow_sample.c
    ../Src/tc_iot_examples/iot_explorer_platform/: iCube_data_template_sample.c light_data_template_sample.c
  group Middlewares/qcloud-iot-sdk-embedded-c/network_at
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/sdk_src/network/at_socket/: at_client.c at_socket_inf.c at_utils.c network_at_tcp.c
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/sdk_src/network/: network_interface.c
  group Middlewares/qcloud-iot-sdk-embedded-c/at_device
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/platform/at_device/esp8266/: at_device_esp8266.c
  group Middlewares/qcloud-iot-sdk-embedded-c/platform
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/platform/os/nonos/: HAL_AT_UART_nonos.c HAL_Device_nonos.c HAL_OS_nonos.c HAL_Timer_nonos.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/IKS01A3
    ../Drivers/BSP/IKS01A3/: iks01a3_env_sensors.c iks01a3_env_sensors_ex.c iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c
software components: CMSIS:CORE 4.3.0
